# Keil uVision project RDA.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RDA +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\SYS;..\HAL\Inc;..\Hardware\Led;..\USER;..\Hardware\OLED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\RS485;..\Hardware\PHMeter;..\Hardware\Turbidimeter;..\Hardware\ConductivityMeter;..\Hardware\DissolvedOxygenMeter;..\Hardware\CRC16
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f030x8.s
  group SYS
    ../SYS/: system_stm32f0xx.c
  group USER
    ./: stm32f0xx_karlboard.c stm32f0xx_it.c stm32f0xx_hal_msp.c main.c i2c.c
  group HAL
    ../HAL/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c stm32f0xx_hal_adc.c stm32f0xx_hal.c stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_i2c_ex.c
  group HARDWARE
    ../Hardware/OLED/: oled.c
    ../Hardware/RS485/: rs485.c
    ../Hardware/PHMeter/: PHMeter.c
    ../Hardware/CRC16/: CRC16.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
